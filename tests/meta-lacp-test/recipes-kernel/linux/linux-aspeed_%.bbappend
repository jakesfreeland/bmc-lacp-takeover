FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://bonding.cfg"
